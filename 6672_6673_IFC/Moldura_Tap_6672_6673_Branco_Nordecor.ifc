Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-15T00:45:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Dec 15 00:45:13 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\3581d617-6b7f-40f0-a361-ccd3f05f70d3\95a183f7-d2d2-48f2-aa07-2f5f452c135c\ifc * Database version: 5507 * Database creation date: Sun Dec 15 00:45:12 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Dec 15 00:45:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Dec 15 00:45:13 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6672 - Branco, Moldura_Tap_6672_6673_Nordecor:6672 - Branco:328340
In: Nível 1
Type - Classification: D5020200 Lighting Equipment (Uniformat); Material: Metal - Alumínio - Branco, Plástico - PC - Preto
Type - Cotas - Altura: 55.5 mm; Comprimento: 64 mm; Comprimento do nicho: 59 mm; Largura: 64 mm; Largura do nicho: 55 mm
Type - Dados - Data da atualização: 14/12/2024; Versão: 1
Type - Dados de identidade - Código de montagem: D5020200; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Moldura com borda, para módulo TAP, acabamento branco; Descrição de montagem: Lighting Equipment; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 anos; Grau de proteção: IP 20; Localização: Camboriú-SC / Brasil; Modelo: 6672; Nome do tipo: 6672 - Branco; Número OmniClass: 23.80.70.11; Tipo de imagem: Imagem raster: 6672.png; Título OmniClass: Luminaries for Internal Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/moldura-para-modulo-tap/
Type - Elétrico - Comentários de voltagem: NA; Lâmpada: NA
Type - Estrutural - Peso: 0
Type - Gráficos - Simbologia: Imagem raster: 6672 2D.png
Type - Materiais e acabamentos - Base: Plástico - PC - Preto; Frame: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Moldura_Tap_6672_6673_Nordecor; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Cotas - Área: 0.0141935 m2; Volume: 0.0000198789 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Moldura_Tap_6672_6673_Nordecor: 6672 - Branco; Família e tipo: Moldura_Tap_6672_6673_Nordecor: 6672 - Branco; ID de tipo: Moldura_Tap_6672_6673_Nordecor: 6672 - Branco; Tipo: Moldura_Tap_6672_6673_Nordecor: 6672 - Branco
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
